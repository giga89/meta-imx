require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=44a8052c384584ba09077e85a3d1654f"

IMX_SRCREV_ABBREV = "c2ff972"

SRC_URI[md5sum] = "0c1d8313ab2f6dcfed1edeab8bc8fa60"
SRC_URI[sha256sum] = "34d27b9804d047ea3cb17fec31f8214becaf336037b871998ef20242ac6b2473"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
