require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ca53281cc0caa7e320d4945a896fb837"

IMX_SRCREV_ABBREV = "c2ff972"

SRC_URI[md5sum] = "79b7edf02a8eafb464b471cc66fc228f"
SRC_URI[sha256sum] = "590a0389d2f62be50ccc9162dad4a79a921be599df454ceec580e3aafd38b9d5"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
